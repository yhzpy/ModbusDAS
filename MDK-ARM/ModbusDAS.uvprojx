# Keil uVision project ModbusDAS.uvprojx, settings and files
target DMA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: DMA +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Drivers;../Middlewares;../Middlewares/FreeRTOS/Portable;../Middlewares/FreeRTOS/include;../Middlewares/FreeRTOS/Portable/RVDS/ARM_CM3;../Middlewares/FreeRTOS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c fsmc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_nor.c stm32f1xx_hal_sram.c stm32f1xx_hal_nand.c stm32f1xx_hal_pccard.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Drivers/BSP
    ../Drivers/BSP/LCD/: lcd.c
    ../Drivers/BSP/DMA/: dma.c
    ../Drivers/BSP/KEY/: key.c
    ../Drivers/BSP/LED/: led.c
    ../DRIVER/DS3231/: ds3231.c
    ../DRIVER/EC11/: ec11.c
    ../DRIVER/MAX485/: max485.c
    ../DRIVER/SHT30/: sht30.c
    ../DRIVER/: flash_log.c i2c1_reg.c spi_reg.c
  group Drivers/SYSTEM
    ../Drivers/SYSTEM/delay/: delay.c
    ../Drivers/SYSTEM/sys/: sys.c
    ../Drivers/SYSTEM/usart/: myusart.c
  group MiddleWares/Usmart
    ../Middlewares/USMART/: usmart.c usmart_config.c usmart_port.c usmart_str.c
  group FreeRTOS/Source
    ../Middlewares/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/Portable
    ../Middlewares/FreeRTOS/Portable/MemMang/: heap_4.c
    ../Middlewares/FreeRTOS/Portable/RVDS/ARM_CM3/: port.c
    ../Middlewares/FreeRTOS/: FreeRTOSConfig.h
software components: CMSIS:CORE 4.3.0
